# Keil uVision project Charger6kW_8.release.uvprojx, settings and files
target AER07 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F334R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Aer_07v2-release +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F334x8 RELEASE
  c include: ..\AER_07K;.\CMSIS\inc;.\User\inc;.\MSP430;.\User\inc;.\STM32F3xx_HAL_Driver\Inc;.\STM32F3xx_HAL_Driver\Inc\Legacy;.\CMSIS\Device\ST\STM32F3xx\Include;.\FreeModbus;.\W25QXX
  asm define: USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8001800 size 0xe800
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Aer_07v2.release.sct
  group CMSIS
    ./CMSIS/src/: system_stm32f3xx.c
  group Startup
    ./Starup/: startup_stm32f334x8.s
  group User
    ./User/src/: main.c HiResTim.c BoardInit.c adc.c termo.c tim3.c
  group MSP430
    ./MSP430/: cfg.c crc16.c flag.c flash.c iqmath.c mainMSP.c meas.c safety.c spi.c stats.c time.c usci.c util.c variant.c lcd.c can.c comms.c ctrl.c io.c status.c pwm.c sch.c telem.c temp.c
  group DCDC
    ./DCDC/: dcdc.c
